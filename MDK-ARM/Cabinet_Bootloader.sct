LR_FLASH 0x08000000 0x20000 {
 ER_CODE 0x08000000 0x20000 { *.o (RESET, +First) *(InRoot$$Sections) .ANY (+RO) }
 RW_RAM 0x24000000 0x80000 { .ANY (+RW +ZI) }
}
