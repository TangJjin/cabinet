LR_FLASH 0x08100000 0x20000 {
 ER_CODE 0x08100000 0x20000 { *.o (RESET, +First) *(InRoot$$Sections) .ANY (+RO) }
 RW_RAM 0x30000000 0x40000 { .ANY (+RW +ZI) }
}
