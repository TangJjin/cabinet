# Keil uVision project MIPIProject.uvprojx, settings and files
target MIPIProject_CM7 (6070000::V6.7::.\ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MIPIProject_CM7 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,USE_FLASH_ECC=0,USE_SDIO_TRANSCEIVER=0,VIRTIO_MASTER_ONLY,NO_ATOMIC_64_SUPPORT,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,RPMSG_BUFFER_SIZE=128,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c misc: -std=gnu11 -Wno-everything -Wall -Wextra -Wno-unused-parameter -Wno-missing-field-initializers
  c include: ../CM7/Core/Inc;../Common/Inc;../Common/Inc/openamp;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/BOARD;../APP/IPC;../APP/LCD;../APP/LED;../APP/QSPI;../APP/RTC;../APP/RTOS;../APP/SDRAM;../APP/SENSOR;../APP/STORAGE;../APP/SYSTEM;../APP/TOUCH;../APP/UART;../APP/UI;../APP/UPDATE;../Middlewares/OpenAMP/open-amp/lib/include;../Middlewares/OpenAMP/libmetal/lib/include;../FreeRTOS/include;../FreeRTOS/portable/GCC/ARM_CM7/r0p1;../lvgl;../lvgl/examples/porting;../Middlewares/FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: MIPIProject_CM7.sct
  link misc: --keep=*(CABINET_INFO)
  group Startup
    ../MDK-ARM/: startup_stm32h747xx_CM7.s startup_stm32h747xx_CM4.s
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Common
    ../Common/Src/: cabinet_core.c cabinet_retarget.c
    ../APP/BOARD/: bsp_board.c
  group FreeRTOS
    ../FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM7/r0p1/: port.c
    ../Common/Src/: cabinet_rtos_hooks.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group OpenAMP
    ../Middlewares/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ../Middlewares/OpenAMP/libmetal/lib/system/generic/: condition.c irq.c time.c generic_device.c generic_init.c generic_io.c
    ../Middlewares/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
    ../Middlewares/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../Middlewares/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ../Middlewares/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
    ../Common/Src/: openamp.c rsc_table.c mbox_hsem.c
    ../APP/IPC/: bsp_ipc.c
  group Application
    ../CM7/Core/Src/: main.c stm32h7xx_hal_msp.c
    ../Common/Src/: cabinet_image.c cabinet_modbus.c cabinet_interrupts.c
    ../CM4/Core/Src/: main.c stm32h7xx_hal_msp.c
  group Storage
    ../APP/QSPI/: bsp_qspi.c
    ../APP/RTC/: bsp_rtc.c
    ../APP/STORAGE/: bsp_sd.c diskio.c
    ../APP/UPDATE/: bsp_update.c
    ../Common/Src/: cabinet_boot.c
    ../Middlewares/FatFs/: ff.c
  group Board display
    ../CM7/Core/Src/: gpio.c dma.c fmc.c usart.c i2c.c dsihost.c ltdc.c dma2d.c
    ../APP/LCD/: bsp_mipi_lcd.c
    ../APP/TOUCH/: bsp_touch.c bsp_touch_i2c.c
    ../APP/SDRAM/: bsp_sdram.c
    ../APP/UART/: bsp_uart.c ringbuffer.c
    ../APP/LED/: bsp_led.c
  group Cabinet
    ../APP/SYSTEM/: bsp_system.c bsp_cabinet.c
    ../APP/UI/: bsp_cabinet_ui.c cabinet_font_24.c
  group LVGL port
    ../lvgl/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group LVGL
    ../lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../lvgl/src/display/: lv_display.c
    ../lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
    ../lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../lvgl/src/drivers/display/drm/: lv_linux_drm.c
    ../lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../lvgl/src/drivers/evdev/: lv_evdev.c
    ../lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
    ../lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../lvgl/src/drivers/qnx/: lv_qnx.c
    ../lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ../lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shell.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
    ../lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../lvgl/src/layouts/flex/: lv_flex.c
    ../lvgl/src/layouts/grid/: lv_grid.c
    ../lvgl/src/layouts/: lv_layout.c
    ../lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgl/src/libs/bmp/: lv_bmp.c
    ../lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../lvgl/src/libs/libpng/: lv_libpng.c
    ../lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../lvgl/src/libs/lz4/: lz4.c
    ../lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/src/libs/rle/: lv_rle.c
    ../lvgl/src/libs/rlottie/: lv_rlottie.c
    ../lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../lvgl/src/: lv_init.c
    ../lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/others/gridnav/: lv_gridnav.c
    ../lvgl/src/others/ime/: lv_ime_pinyin.c
    ../lvgl/src/others/imgfont/: lv_imgfont.c
    ../lvgl/src/others/monkey/: lv_monkey.c
    ../lvgl/src/others/observer/: lv_observer.c
    ../lvgl/src/others/snapshot/: lv_snapshot.c
    ../lvgl/src/others/sysmon/: lv_sysmon.c
    ../lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../lvgl/src/stdlib/: lv_mem.c
    ../lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../lvgl/src/themes/default/: lv_theme_default.c
    ../lvgl/src/themes/: lv_theme.c
    ../lvgl/src/themes/mono/: lv_theme_mono.c
    ../lvgl/src/themes/simple/: lv_theme_simple.c
    ../lvgl/src/tick/: lv_tick.c
    ../lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../lvgl/src/widgets/animimage/: lv_animimage.c
    ../lvgl/src/widgets/arc/: lv_arc.c
    ../lvgl/src/widgets/bar/: lv_bar.c
    ../lvgl/src/widgets/button/: lv_button.c
    ../lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/widgets/canvas/: lv_canvas.c
    ../lvgl/src/widgets/chart/: lv_chart.c
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl/src/widgets/image/: lv_image.c
    ../lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/widgets/label/: lv_label.c
    ../lvgl/src/widgets/led/: lv_led.c
    ../lvgl/src/widgets/line/: lv_line.c
    ../lvgl/src/widgets/list/: lv_list.c
    ../lvgl/src/widgets/lottie/: lv_lottie.c
    ../lvgl/src/widgets/menu/: lv_menu.c
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../lvgl/src/widgets/roller/: lv_roller.c
    ../lvgl/src/widgets/scale/: lv_scale.c
    ../lvgl/src/widgets/slider/: lv_slider.c
    ../lvgl/src/widgets/span/: lv_span.c
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/widgets/spinner/: lv_spinner.c
    ../lvgl/src/widgets/switch/: lv_switch.c
    ../lvgl/src/widgets/table/: lv_table.c
    ../lvgl/src/widgets/tabview/: lv_tabview.c
    ../lvgl/src/widgets/textarea/: lv_textarea.c
    ../lvgl/src/widgets/tileview/: lv_tileview.c
    ../lvgl/src/widgets/win/: lv_win.c
  group HAL
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c
  group Sensors
    ../APP/SENSOR/: bsp_sensor.c
  group Boot
    ../Bootloader/CM7/: main.c
    ../Bootloader/CM4/: main.c
target MIPIProject_CM4 (6070000::V6.7::.\ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x10000000-0x10047FFF) IROM(0x8100000-0x81FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M4") TZ
  output: MIPIProject_CM4 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,USE_FLASH_ECC=0,USE_SDIO_TRANSCEIVER=0,VIRTIO_SLAVE_ONLY,NO_ATOMIC_64_SUPPORT,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,RPMSG_BUFFER_SIZE=128,LV_LVGL_H_INCLUDE_SIMPLE,LV_CONF_INCLUDE_SIMPLE
  c misc: as above
  c include: ../CM4/Core/Inc;../Common/Inc;../Common/Inc/openamp;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/BOARD;../APP/IPC;../APP/LCD;../APP/LED;../APP/QSPI;../APP/RTC;../APP/RTOS;../APP/SDRAM;../APP/SENSOR;../APP/STORAGE;../APP/SYSTEM;../APP/TOUCH;../APP/UART;../APP/UI;../APP/UPDATE;../Middlewares/OpenAMP/open-amp/lib/include;../Middlewares/OpenAMP/libmetal/lib/include;../FreeRTOS/include;../FreeRTOS/portable/GCC/ARM_CM4F;../lvgl;../lvgl/examples/porting
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: MIPIProject_CM4.sct
  link misc: --keep=*(CABINET_INFO)
target Cabinet_Bootloader (6070000::V6.7::.\ARMCLANG)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Cabinet_Bootloader +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,USE_FLASH_ECC=0,USE_SDIO_TRANSCEIVER=0,CABINET_BOOTLOADER
  c misc: as above
  c include: ../CM7/Core/Inc;../Common/Inc;../Common/Inc/openamp;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/BOARD;../APP/IPC;../APP/LCD;../APP/LED;../APP/QSPI;../APP/RTC;../APP/RTOS;../APP/SDRAM;../APP/SENSOR;../APP/STORAGE;../APP/SYSTEM;../APP/TOUCH;../APP/UART;../APP/UI;../APP/UPDATE;../Middlewares/FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: Cabinet_Bootloader.sct
target Cabinet_CM4_Gate (6070000::V6.7::.\ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: Cabinet_CM4_Gate +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,USE_FLASH_ECC=0,USE_SDIO_TRANSCEIVER=0,CABINET_CM4_GATE
  c misc: as above
  c include: ../CM4/Core/Inc;../Common/Inc;../Common/Inc/openamp;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../APP/BOARD;../APP/IPC;../APP/LCD;../APP/LED;../APP/QSPI;../APP/RTC;../APP/RTOS;../APP/SDRAM;../APP/SENSOR;../APP/STORAGE;../APP/SYSTEM;../APP/TOUCH;../APP/UART;../APP/UI;../APP/UPDATE
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: Cabinet_CM4_Gate.sct
